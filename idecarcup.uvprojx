# Keil uVision project idecarcup.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: idecarcup
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: DriveMotor.c DriveMotor.h Steering.c Steering.h main.c Camera.c Camera.h uart.c uart.h Config.h pid.c pid.h Tuning.c Tuning.h leds.c leds.h switch.h switch.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
